# Keil uVision project Cooperative_Scheduler.uvprojx, settings and files
target stm32f4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00180000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Cooperative_Scheduler
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group osKernel
    ./: osKernel.s osKernel.h osKernel.c
  group user
    ./: main.c
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.2
